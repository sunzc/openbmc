OBMC_IMAGE_EXTRA_INSTALL:append:qemux86_64 = " helloworld"
